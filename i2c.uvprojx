# Keil uVision project i2c.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: i2c
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./: main.c global.h
  group i2clib
    ./: I2C.c I2C.h
  group init_gpio
    ./: my_gpio.c my_gpio.h
  group init_rcc
    ./: init_rcc.c init_rcc.h
  group init_delay
    ./: my_delay.c my_delay.h
  group init_timer
    ./: init_timer.c init_timer.h
  group init_button
    ./: button.c button.h
  group math
    ./: my_math.c my_math.h
  group usart_ring
    ./: usart_better.c usart_better.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
